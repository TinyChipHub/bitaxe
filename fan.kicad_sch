File: fan.kicad_sch (KiCad schematic)
At the start: 14 parts, among them J6 Conn_01x04, U10 EMC2101

Commit message: add fixture
Parts:
- renumbered R51 to R24
